# Keil uVision project Star Gamer ELF.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Star Gamer ELF - 2048
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: .;.\lib;..\EXTERN API
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\dll_generate.sct
  link misc: --base_platform --entry=dl_main  --no_comment_section --no_debug --export_dynamic
  group Source Group 1
    ./: game_2048.c dl_User_api.c
    ./lib/: dl_string_lib.c
