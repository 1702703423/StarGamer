# Keil uVision project Star Gamer.uvprojx, settings and files
target Star Gamer (6190000::V6.19::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Star Gamer +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=4 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -Wno-deprecated-non-prototype
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../System;../../StarGamer;../MDK-ARM;../LIBJPEG/App;../LIBJPEG/Target;../Middlewares/Third_Party/LibJPEG/include;../Middlewares/Third_Party/NES;../Middlewares/libhelix;../Middlewares/libhelix/port;../Drivers/LCD;../Debug;../Debug/fs_support;../Debug/shell_support;../Media;../BSP;../Middlewares/Third_Party/LVGL/GUI/lvgl;../Middlewares/Third_Party/LVGL/GUI/lvgl/src;../Middlewares/Third_Party/LVGL/GUI;../Middlewares/Third_Party/LVGL/GUI/lvgl/examples/porting;../Middlewares/Third_Party/LVGL/GUI_APP/demos/stress;../Middlewares/Third_Party/LVGL/GUI_APP/demos;../APP/Arduboy;../Middlewares/Third_Party/Arduboy/src;../Middlewares/Third_Party/Arduboy/Buttons;../Middlewares/Third_Party/Arduboy/Dino;../Middlewares/Third_Party/Arduboy/FlappyBall;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;..\ELF Loader
  asm include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Debug
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\System\StarGamer_CCM.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_rng.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Middlewares/Helix
    ../Middlewares/libhelix/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c mp3dec.h
    ../Middlewares/libhelix/port/: helix_support.c helix_support.h
    ../Middlewares/libhelix/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Debug
    ../Debug/: shell.c shell.h shell_cfg.h shell_cmd_list.c shell_companion.c shell_ext.c shell_ext.h UART1_Debug.c
    ../Debug/fs_support/: shell_fs.c shell_fs.h
    ../Debug/shell_support/: shell_support.c shell_support.h
  group Drivers/LCD
    ../Drivers/LCD/: LCD.c LCD.h LCD_Font.h
  group System
    ../System/: sys.c sys.h Malloc.c Malloc.h adt_chain.c System_Status.c System_Status.h adt_chain.h firmware.h firmware_start.c
  group App
    ../Media/: Player.c Player.h Player_Codec.h Player_WAV.c Player_WAV.h Player_MP3.c Player_MP3.h
    ../APP/Arduboy/: Arduboy_Games.c Arduboy_Games.h Arduboy_Port.c Arduboy_Port.h Arduboy_Runtime.c Arduboy_Runtime.h
  group Application/User/LIBJPEG/App
    ../LIBJPEG/App/: libjpeg.c
  group Application/User/LIBJPEG/Target
    ../LIBJPEG/Target/: jdata_conf.c
  group Middlewares/LibJPEG
    ../Middlewares/Third_Party/LibJPEG/source/: jcapimin.c jcapistd.c jdapimin.c jdapistd.c jcomapi.c jcparam.c jctrans.c jdtrans.c jcinit.c jcmaster.c jcmainct.c jcprepct.c jccoefct.c jccolor.c jcsample.c jcdctmgr.c jfdctint.c jfdctfst.c jfdctflt.c jchuff.c jcarith.c jcmarker.c jdatadst.c jdmaster.c jdinput.c jdmainct.c jdcoefct.c jdpostct.c jdmarker.c jdhuff.c jdarith.c jddctmgr.c jidctint.c jidctfst.c jidctflt.c jdsample.c jdcolor.c jdmerge.c jquant1.c jquant2.c jdatasrc.c jaricom.c jerror.c jmemmgr.c jutils.c jmemnobs.c
  group GUI
    ../GUI/: GUI_Task.c GUI_Main.c GUI_Main.h GUI_Manage.c GUI_Manage.h GUI_FileManage.c GUI_FileManage.h GUI_NES.c GUI_NES.h GUI_Player.c GUI_Player.h GUI_Settings.c GUI_Settings.h GUI_Image.c GUI_Image.h GUI_Font.c GUI_Font.h GUI_Text.c GUI_Text.h GUI_Start.c GUI_Start.h GUI_Arduboy.c GUI_Arduboy.h
  group Middlewares/Arduboy
    ../Middlewares/Third_Party/Arduboy/src/: arduboy_core.c arduboy_core.h arduboy.c arduboy.h
    ../Middlewares/Third_Party/Arduboy/Buttons/: ArduboyButtons.c
    ../Middlewares/Third_Party/Arduboy/Dino/: Dino.c
    ../Middlewares/Third_Party/Arduboy/FlappyBall/: FlappyBall.c
  group Middlewares/NES
    ../Middlewares/Third_Party/NES/: 6502.s nes_apu.c nes_apu.h nes_crc32.c nes_main.c nes_main.h nes_mapper.c nes_mapper.h nes_ppu.c nes_ppu.h
  group ELF Loader
    ../ELF Loader/: dl_arch.c dl_elf.h dl_lib.c dl_lib.h dl_port.c dl_port.h dl_user_api.h dl_vector.c
  group ELF Loader/common
    ../ELF Loader/common/: dl_extern_lib.h dl_string_lib.h
  group BSP
    ../BSP/: i2s.c i2s.h w25q64.c w25q64.h at24c02.c at24c02.h key.c key.h
  group Middlewares/LVGL
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Middlewares/Third_Party/LVGL/GUI_APP/demos/stress/: lv_demo_stress.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
software components: CMSIS:CORE 5.6.0
